# IAR project Backup of SeekFree_Kinetis.ewp, settings and files
configuration MK60DN_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60FX512xxx15 NXP MK60FX512xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MK60FX; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\USER\inc; ..\..\USER\src; ..\..\..\Libraries\startup\CoreSupport; ..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\Libraries\startup\DeviceSupport; ..\..\..\Libraries\drives\inc; ..\..\..\Libraries\seekfree; ..\..\..\Libraries\FatFs; ..\..\..\Libraries\FatFs\option
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SeekFree_Kinetis.srec
  ILINK.IlinkOutputFile: SeekFree_Kinetis.out
  ILINK.IlinkIcfFile: linker\MK60xX512_15.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MK60FX_Debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  group drives/inc
    ../../../Libraries/drives/inc/: common.h misc.h MK60_adc.h MK60_cmt.h MK60_dac.h MK60_dma.h MK60_flash.h MK60_ftm.h MK60_gpio.h MK60_i2c.h MK60_lptmr.h MK60_pit.h MK60_port.h MK60_port_cfg.h MK60_rtc.h MK60_sdhc.h MK60_spi.h MK60_systick.h MK60_uart.h MK60_wdog.h
  group drives/src
    ../../../Libraries/drives/src/: common.c misc.c MK60_adc.c MK60_cmt.c MK60_dac.c MK60_dma.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_pit.c MK60_port.c MK60_rtc.c MK60_sdhc.c MK60_spi.c MK60_systick.c MK60_uart.c MK60_wdog.c
  group fatfs
    ../../../Libraries/FatFs/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
  group seekfree
    ../../../Libraries/seekfree/: BMX055.c BMX055.h font.c font.h SEEKFREE_FUN.c SEEKFREE_FUN.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_OLED.c SEEKFREE_OLED.h
  group startup
    ../../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_MK60D10.s startup_MK60F15.s
    ../../../Libraries/startup/DeviceSupport/: system_MK60.c
  group user_c
    ../../USER/src/: Attitude_Calculation.c communicate.c control.c init.c isr.c main.c other.c systemUI.c
  group user_h
    ../../USER/inc/: Attitude_Calculation.h communicate.h control.h init.h isr.h other.h systemUI.h
    ../../../Libraries/drives/inc/: headfile.h
