<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\program\Backup of SeekFree_LPC546XX.ewp</path>
    </project>
    <batchBuild />
</workspace>
