# IAR project Backup of SeekFree_LPC546XX.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54606J512 NXP LPC54606J512
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\..\USER\inc; ..\..\USER\src; ..\..\..\Libraries\startup\CoreSupport; ..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\Libraries\startup\DeviceSupport; ..\..\..\Libraries\drives\inc; ..\..\..\Libraries\seekfree; ..\..\..\Libraries\drives\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SeekFree_LPC546XX.srec
  ILINK.IlinkOutputFile: SeekFree_LPC546XX.out
  ILINK.IlinkIcfFile: SeekFree_LPC546XX.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group drives/common
    ../../../Libraries/drives/common/: assert.c assert.h common.c common.h misc.c misc.h SEEKFREE_PRINTF.c SEEKFREE_PRINTF.h
  group drives/inc
    ../../../Libraries/drives/inc/: LPC546XX_adc.h LPC546XX_ctimer.h LPC546XX_dma.h LPC546XX_eeprom.h LPC546XX_flexcomm.h LPC546XX_gint.h LPC546XX_gpio.h LPC546XX_iic.h LPC546XX_iocon.h LPC546XX_mrt.h LPC546XX_pint.h LPC546XX_pit.h LPC546XX_pll.h LPC546XX_sct.h LPC546XX_spi.h LPC546XX_systick.h LPC546XX_uart.h
  group drives/src
    ../../../Libraries/drives/src/: LPC546XX_adc.c LPC546XX_ctimer.c LPC546XX_dma.c LPC546XX_eeprom.c LPC546XX_flexcomm.c LPC546XX_gint.c LPC546XX_gpio.c LPC546XX_iic.c LPC546XX_iocon.c LPC546XX_mrt.c LPC546XX_pint.c LPC546XX_pit.c LPC546XX_pll.c LPC546XX_sct.c LPC546XX_spi.c LPC546XX_systick.c LPC546XX_uart.c
  group seekfree
    ../../../Libraries/seekfree/: SD_SPI.c SD_SPI.h SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_FONT.c SEEKFREE_FONT.h SEEKFREE_FUN.c SEEKFREE_FUN.h SEEKFREE_MT9V032.c SEEKFREE_MT9V032.h
  group startup
    ../../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_LPC54606.s
    ../../../Libraries/startup/DeviceSupport/: system_LPC54606.c system_LPC54606.h
  group user_c
    ../../USER/src/: communicate.c imgProcess.c isr.c main.c other.c searchLine.c systemUI.c
    ../../../Libraries/: version.txt YinJiaoShuoMing.txt
  group user_h
    ../../USER/inc/: communicate.h Define.h imgProcess.h isr.h LPC546XX_config.h other.h searchLine.h systemUI.h
    ../../../Libraries/drives/inc/: headfile.h
